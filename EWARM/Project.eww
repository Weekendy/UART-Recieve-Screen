<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\UART_Show_F103C8T6.ewp</path>
  </project>
  <batchBuild />
</workspace>
